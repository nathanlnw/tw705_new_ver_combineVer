# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f2xx (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32f2xx
  AfterMake: fromelf --bin --output=.\build\app.bin .\build\rtthread-stm32f2xx.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS
  c include: .;..\..\components\dfs;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\romfs;..\..\components\dfs\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\STM32_USB_HOST_Library\Class\MSC\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;applications;.\applications\lcd;drivers;..\..\components\drivers\include;.\common;.\STM32F2xx_Libraries\STM32F2xx_StdPeriph_Driver\inc;.\STM32F2xx_Libraries\CMSIS\ST\STM32F2xx\Include;.\applications\GB19056;.\applications\large_lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: jt808.c hmi.c msglist.c jt808_sprintf.c jt808_param.c tree_config.c jt808_gps.c jt808_camera.c jt808_area.c jt808_update.c jt808_misc.c jt808_gps_pack.c jt808_util.c jt808_vehicle.c jt808_sms.c tj_taxi_v01.c tj_mixers_v01.c jt808_SpeedFatigue.c
  group Drivers
    drivers/: board.c usb_bsp.c usbh_usr.c
    ./drivers/: printer.c usbh.c gps.c mma8451.c vuart.c m66.c sst25.c rs485.c camera.c rtc.c SLE4442.c diskio_sd.c sd_test.c SPI_SD_driver.c can.c RS232.c
    ../../components/drivers/src/: ringbuffer.c
    ./applications/: jt808_can.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/STM32_USB_HOST_Library/Core/src/: usbh_hcs.c usbh_ioreq.c usbh_core.c usbh_stdreq.c
    STM32F4xx_Libraries/STM32_USB_HOST_Library/Class/Msc/src/: usbh_msc_bot.c usbh_msc_core.c
    STM32F4xx_Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ./STM32F4xx_Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c
    ./STM32F2xx_Libraries/CMSIS/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ./STM32F2xx_Libraries/CMSIS/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ./STM32F2xx_Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c misc.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: ff.c diskio.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../components/dfs/filesystems/elmfat/option/: cc936.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group lcd
    ./applications/lcd/: Menu_2_1_Status8.c Menu_2_2_Speed15.c Menu_2_3_CentreTextStor.c Menu_2_4_CarInfor.c Menu_2_5_DriverInfor.c Menu_2_6_Mileage.c Menu_2_7_RequestProgram.c Menu_2_8_DnsIpDisplay.c Menu_2_InforCheck.c Menu_3_1_CentreQuesSend.c Menu_3_2_FullorEmpty.c Menu_3_3_ElectronicInfor.c Menu_3_4_Multimedia.c Menu_3_5_MultimediaTrans.c Menu_3_6_Record.c Menu_3_7_Affair.c Menu_3_8_LogOut.c Menu_3_InforInteract.c Menu_4_1_pilao.c Menu_4_2_chaosu.c Menu_5_1_TelDis.c Menu_5_2_TelAtd.c menu_5_3_bdupgrad.c Menu_5_5_Can.c Menu_5_6_Concuss.c Menu_5_7_Version.c Menu_5_8_usb.c Menu_5_other.c Menu_7_CentreTextDisplay.c Menu_Include.c SED1520.c menu_popup.c Menu_0_0_password.c Menu_0_0_type.c Menu_0_1_License.c Menu_0_2_CarType.c Menu_0_3_Sim.c Menu_0_4_VIN.c Menu_0_5_Colour.c Menu_0_loggingin.c Menu_6_SetInfor.c Menu_param_set_01.c Menu_1_Idle.c Menu_0_6_PulseCoefficient.c Menu_0_7_oil.c Menu_5_9_debug.c Menu_flash_err.c Menu_8_SetDNS.c Menu_0_2_SpeedType.c Menu_setting_param.c Menu_8_1_MainDnsPort.c Menu_1_menu.c Menu_4_3_PulseCoefficient.c Menu_4_4_ExportData.c Menu_4_5_ICcard.c Menu_4_7_speedlog.c Menu_4_recorder.c Menu_8_2_AuxDnsPort.c Menu_8_3_MainIpPort.c Menu_8_4_AuxIpPort.c
  group Common
    ./common/: common.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group GB19056
    ./applications/GB19056/: gb_inject.c gb_vdr.c jt808_GB19056.c
  group large_lcd
    ./applications/large_lcd/: large_lcd.c
target TJ_TAXI_V01 (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  cpu: as above
  output: rtthread-stm32f2xx
  AfterMake: fromelf --bin --output=.\TJ_TAXI_V01\app.bin .\build\rtthread-stm32f2xx.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,TJ_TAXI_V01
  c include: .;..\..\components\dfs;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\romfs;..\..\components\dfs\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\STM32_USB_HOST_Library\Class\MSC\inc;STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;applications;.\applications\lcd;drivers;..\..\components\drivers\include;.\common;.\STM32F2xx_Libraries\STM32F2xx_StdPeriph_Driver\inc;.\STM32F2xx_Libraries\CMSIS\ST\STM32F2xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
target TJ_Mixers_V01 (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  cpu: as above
  output: rtthread-stm32f2xx
  AfterMake: fromelf --bin --output=.\TJ_Mixers_V01\app.bin .\build\rtthread-stm32f2xx.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,TJ_MIXERS_V01,STM32F2XX,USE_USB_OTG_FS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
target BJ_XGX_V01 (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  cpu: as above
  output: rtthread-stm32f2xx
  AfterMake: fromelf --bin --output=.\BJ_XGX_V01\app.bin .\build\rtthread-stm32f2xx.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,BJ_XGX_V01
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
